# Keil uVision project NewTest.uvprojx, settings and files
target NewTest (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NewTest +hex
  c flags: Optim=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: STM32F10X_HD
  c include: ..\DRIVE\COMMUNICATION;..\DRIVE\DataChange;..\DRIVE\UART;..\SYSTEM\delay;..\SYSTEM\sys;..\DRIVE\TIME;..\DRIVE\ENCAPSULATION
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ../SYSTEM/: startup_stm32f10x_hd.s
  group USER
    ../USER/: main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group DRIVE
    ../DRIVE/COMMUNICATION/: communication.c
    ../DRIVE/DataChange/: DataChange.c
    ../DRIVE/ENCAPSULATION/: encapsulation.c
    ../DRIVE/UART/: uart.c
software components: CMSIS:CORE 5.0.1
