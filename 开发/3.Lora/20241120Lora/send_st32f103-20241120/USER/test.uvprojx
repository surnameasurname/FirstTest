# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: STM32F10X_MD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\ADC;..\HARDWARE\UART;..\HARDWARE\TIME;..\HARDWARE\STMFLASH;..\HARDWARE\COMMUNICATION;..\HARDWARE\Equipment;..\HARDWARE\DataChange;..\HARDWARE\SHOW;..\HARDWARE\LORA;..\HARDWARE\MySPI
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/UART/: uart.c
    ../HARDWARE/TIME/: time.c
    ../HARDWARE/COMMUNICATION/: communication1.c
    ../HARDWARE/Equipment/: equipment.c
    ../HARDWARE/DataChange/: DataChange.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/SHOW/: show1.c
    ../HARDWARE/LORA/: lora.c radio.c sx126x_driver.c utilities.c
    ../HARDWARE/MySPI/: MySPI.c
software components: CMSIS:CORE 5.0.1
