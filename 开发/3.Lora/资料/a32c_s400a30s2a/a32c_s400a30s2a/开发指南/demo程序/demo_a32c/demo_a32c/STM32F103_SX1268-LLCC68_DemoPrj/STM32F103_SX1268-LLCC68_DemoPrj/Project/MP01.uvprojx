# Keil uVision project MP01.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 32101 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Project;..\Core;..\FWlib\inc;..\SYSTEM\inc;..\LED;..\KEY;..\UASRT;..\TIM;..\drv_periph\inc;..\utilities\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_hd.s
    ./: stm32f10x_it.c system_stm32f10x.c
  group Fwlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_usart.c stm32f10x_tim.c
  group System
    ../SYSTEM/src/: delay.c sys.c
  group Main
    ./: main.c
    ../LED/: LED.c
    ../UASRT/: uart.c
    ../TIM/: TIM.c
  group Drv_Periph
    ../drv_periph/src/: radio.c sx126x_driver.c Drv_spi.c
  group utilities
    ../utilities/src/: utilities.c
