# Keil uVision project Emm42_STM32_UART.uvprojx, settings and files
target Emm42_STM32_WHILE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\APP;..\BSP;..\CMSIS;..\DRIVERS;..\LIB\STM32F10x_StdPeriph_Lib_V3.5.0\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: Emm42_main.c stm32f10x_conf.h stm32f10x_it.c
  group BSP
    ../BSP/: Emm42_usart.c Emm42_usart.h Emm42_board.c Emm42_board.h
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group DRIVERS
    ../DRIVERS/: Emm42_delay.c Emm42_delay.h
  group STM32F10x_StdPeriph_Lib_V3.5.0
    ../LIB/STM32F10x_StdPeriph_Lib_V3.5.0/src/: stm32f10x_gpio.c stm32f10x_rcc.c
    ../../../脉冲控制例程/while循环发脉冲/stm32/LIB/STM32F10x_StdPeriph_Lib_V3.5.0/src/: stm32f10x_usart.c misc.c
