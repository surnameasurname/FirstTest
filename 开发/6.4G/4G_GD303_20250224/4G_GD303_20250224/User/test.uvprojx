# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303CB GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RKB1223_v1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_SD,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\FWLib\GD32F30x_standard_peripheral\Include;..\FWLib\CMSIS;..\FWLib\CMSIS\GD\GD32F30x\Include;..\User;..\Funcs;..\DspLib\Include;..\Funcs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group fwlib
    ../FWLib/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group core
    ../FWLib/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group user
    ./: main.c gd32f30x_it.c
    ../FWLib/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group func
    ../Funcs/: systick.c usart0.c led.c Drv_spi.c radio.c sx126x_driver.c utilities.c delay.c communication1.c timer.c drv_pwm.c adc.c
  group dsp
    ../DspLib/: arm_cortexM4lf_math.lib
